FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://fix-find-path.patch"
